# Keil uVision project FriboxPAC2.uvprojx, settings and files
target FriboxPAC2 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FriboxPAC2 +hex
  AfterMake: xcopy *.hex Firmware /Y
  c flags: Optim=3 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\app;..\..\hal;..\..\lib\inc;..\..\sys;..\..\app\display
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../app/: main.c Button.c PMS7003.c ir.c Wifi.c Motor.c
    ../../app/display/: ili9341.c
  group sys
    ../../sys/: Sys.c SysTimer.c SysButton.c
  group hal
    ../../hal/: HalCommon.c HalFlash.c HalGPIO.c HalTimer.c HalUart.c HalPwm.c HalSPI.c HalWait.c HalLED.c
  group lib
    ../../lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group ::Device
    RTE/Device/STM32F103R8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
